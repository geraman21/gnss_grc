options:
  parameters:
    generate_options: qt_gui
    id: receive_test
    output_language: python
    title: GPS L1 SDR CTTC
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: dll_nbw
  id: variable
  parameters:
    value: '4'
  states: {}
- name: im_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: pll_nbw
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/german/Documents/Thesis/2013_04_04_GNSS_SIGNAL_at_CTTC_SPAIN.dat
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gnss_acquisition_0
  id: gnss_acquisition
  parameters:
    a_channelNum: '6'
    a_sampleFreq: samp_rate
    im_freq: im_freq
  states: {}
- name: gnss_channel_starter_0_0_0_0
  id: gnss_channel_starter
  parameters:
    attempts: '10'
    im_freq: im_freq
    s_sampleFreq: samp_rate
  states: {}
- name: gnss_channel_starter_0_0_0_0_0_0_0
  id: gnss_channel_starter
  parameters:
    attempts: '10'
    im_freq: im_freq
    s_sampleFreq: samp_rate
  states: {}
- name: gnss_channel_starter_0_0_0_0_0_0_0_0
  id: gnss_channel_starter
  parameters:
    attempts: '10'
    im_freq: im_freq
    s_sampleFreq: samp_rate
  states: {}
- name: gnss_data_distributor_0
  id: gnss_data_distributor
  parameters:
    numSamples: 2.5*samp_rate/1000
  states: {}
- name: gnss_decimator_0
  id: gnss_decimator
  parameters:
    sample_freq: samp_rate
  states: {}
- name: gnss_decimator_0_0
  id: gnss_decimator
  parameters:
    sample_freq: samp_rate
  states: {}
- name: gnss_decimator_0_1
  id: gnss_decimator
  parameters:
    sample_freq: samp_rate
  states: {}
- name: gnss_decimator_0_1_0
  id: gnss_decimator
  parameters:
    sample_freq: samp_rate
  states: {}
- name: gnss_decimator_0_1_0_0
  id: gnss_decimator
  parameters:
    sample_freq: samp_rate
  states: {}
- name: gnss_decimator_0_2
  id: gnss_decimator
  parameters:
    sample_freq: samp_rate
  states: {}
- name: gnss_ephemerides_0
  id: gnss_ephemerides
  parameters: {}
  states: {}
- name: gnss_nav_decoding_0
  id: gnss_nav_decoding
  parameters:
    _sampleFreq: samp_rate
    channelNum: '0'
  states: {}
- name: gnss_nav_decoding_0_0
  id: gnss_nav_decoding
  parameters:
    _sampleFreq: samp_rate
    channelNum: '1'
  states: {}
- name: gnss_nav_decoding_0_0_0
  id: gnss_nav_decoding
  parameters:
    _sampleFreq: samp_rate
    channelNum: '2'
  states: {}
- name: gnss_nav_decoding_0_0_0_0
  id: gnss_nav_decoding
  parameters:
    _sampleFreq: samp_rate
    channelNum: '3'
  states: {}
- name: gnss_nav_decoding_0_0_0_0_0
  id: gnss_nav_decoding
  parameters:
    _sampleFreq: samp_rate
    channelNum: '4'
  states: {}
- name: gnss_nav_decoding_0_0_0_0_1
  id: gnss_nav_decoding
  parameters:
    _sampleFreq: samp_rate
    channelNum: '5'
  states: {}
- name: gnss_nav_solution_0
  id: gnss_nav_solution
  parameters:
    _sampleFreq: samp_rate
    _updateRate: '2'
  states: {}
- name: gnss_tracking_ff_0
  id: gnss_tracking_ff
  parameters:
    _channelNum: '0'
    _sampleFreq: samp_rate
    dll_nbw: dll_nbw
    pll_nbw: pll_nbw
  states: {}
- name: gnss_tracking_ff_0_0
  id: gnss_tracking_ff
  parameters:
    _channelNum: '1'
    _sampleFreq: samp_rate
    dll_nbw: dll_nbw
    pll_nbw: pll_nbw
  states: {}
- name: gnss_tracking_ff_0_0_0
  id: gnss_tracking_ff
  parameters:
    _channelNum: '2'
    _sampleFreq: samp_rate
    dll_nbw: dll_nbw
    pll_nbw: pll_nbw
  states: {}
- name: gnss_tracking_ff_0_0_0_0
  id: gnss_tracking_ff
  parameters:
    _channelNum: '3'
    _sampleFreq: samp_rate
    dll_nbw: dll_nbw
    pll_nbw: pll_nbw
  states: {}
- name: gnss_tracking_ff_0_0_0_0_0
  id: gnss_tracking_ff
  parameters:
    _channelNum: '5'
    _sampleFreq: samp_rate
    dll_nbw: dll_nbw
    pll_nbw: pll_nbw
  states: {}
- name: gnss_tracking_ff_0_0_0_0_0_0
  id: gnss_tracking_ff
  parameters:
    _channelNum: '4'
    _sampleFreq: samp_rate
    dll_nbw: dll_nbw
    pll_nbw: pll_nbw
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 0,0
    label1: PRN 32
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '15000'
    ymin: '-15000'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 0,1
    label1: PRN 23
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '15000'
    ymin: '-15000'
  states: {}
- name: qtgui_time_sink_x_0_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 1,0
    label1: PRN 1
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '15000'
    ymin: '-15000'
  states: {}
- name: qtgui_time_sink_x_0_0_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 1,1
    label1: PRN 11
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '15000'
    ymin: '-15000'
  states: {}
- name: qtgui_time_sink_x_0_0_3_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 2,0
    label1: PRN 17
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '15000'
    ymin: '-15000'
  states: {}
- name: qtgui_time_sink_x_0_0_3_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 2,1
    label1: PRN 20
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '15000'
    ymin: '-15000'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_1, '0']
- [blocks_throttle_1, '0', gnss_data_distributor_0, '0']
- [gnss_acquisition_0, acquisition, gnss_data_distributor_0, acquisition]
- [gnss_acquisition_0, acquisition, gnss_tracking_ff_0, acquisition]
- [gnss_acquisition_0, acquisition, gnss_tracking_ff_0_0, acquisition]
- [gnss_acquisition_0, acquisition, gnss_tracking_ff_0_0_0, acquisition]
- [gnss_acquisition_0, acquisition, gnss_tracking_ff_0_0_0_0, acquisition]
- [gnss_acquisition_0, acquisition, gnss_tracking_ff_0_0_0_0_0, acquisition]
- [gnss_acquisition_0, acquisition, gnss_tracking_ff_0_0_0_0_0_0, acquisition]
- [gnss_channel_starter_0_0_0_0, acquisition, gnss_data_distributor_0, acquisition]
- [gnss_channel_starter_0_0_0_0, acquisition, gnss_tracking_ff_0, acquisition]
- [gnss_channel_starter_0_0_0_0, acquisition, gnss_tracking_ff_0_0, acquisition]
- [gnss_channel_starter_0_0_0_0_0_0_0, acquisition, gnss_data_distributor_0, acquisition]
- [gnss_channel_starter_0_0_0_0_0_0_0, acquisition, gnss_tracking_ff_0_0_0, acquisition]
- [gnss_channel_starter_0_0_0_0_0_0_0, acquisition, gnss_tracking_ff_0_0_0_0, acquisition]
- [gnss_channel_starter_0_0_0_0_0_0_0_0, acquisition, gnss_data_distributor_0, acquisition]
- [gnss_channel_starter_0_0_0_0_0_0_0_0, acquisition, gnss_tracking_ff_0_0_0_0_0, acquisition]
- [gnss_channel_starter_0_0_0_0_0_0_0_0, acquisition, gnss_tracking_ff_0_0_0_0_0_0, acquisition]
- [gnss_data_distributor_0, '0', gnss_tracking_ff_0, '0']
- [gnss_data_distributor_0, '0', gnss_tracking_ff_0_0, '0']
- [gnss_data_distributor_0, '0', gnss_tracking_ff_0_0_0, '0']
- [gnss_data_distributor_0, '0', gnss_tracking_ff_0_0_0_0, '0']
- [gnss_data_distributor_0, '0', gnss_tracking_ff_0_0_0_0_0, '0']
- [gnss_data_distributor_0, '0', gnss_tracking_ff_0_0_0_0_0_0, '0']
- [gnss_data_distributor_0, data_vector, gnss_acquisition_0, data_vector]
- [gnss_decimator_0, '0', gnss_nav_decoding_0, '0']
- [gnss_decimator_0, '0', qtgui_time_sink_x_0_0, '0']
- [gnss_decimator_0_0, '0', gnss_nav_decoding_0_0, '0']
- [gnss_decimator_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [gnss_decimator_0_1, '0', gnss_nav_decoding_0_0_0_0, '0']
- [gnss_decimator_0_1, '0', qtgui_time_sink_x_0_0_3, '0']
- [gnss_decimator_0_1_0, '0', gnss_nav_decoding_0_0_0_0_1, '0']
- [gnss_decimator_0_1_0, '0', qtgui_time_sink_x_0_0_3_0_0, '0']
- [gnss_decimator_0_1_0_0, '0', gnss_nav_decoding_0_0_0_0_0, '0']
- [gnss_decimator_0_1_0_0, '0', qtgui_time_sink_x_0_0_3_0, '0']
- [gnss_decimator_0_2, '0', gnss_nav_decoding_0_0_0, '0']
- [gnss_decimator_0_2, '0', qtgui_time_sink_x_0_0_2, '0']
- [gnss_ephemerides_0, ephemeris, gnss_nav_solution_0, ephemeris]
- [gnss_nav_decoding_0, '0', gnss_nav_solution_0, '0']
- [gnss_nav_decoding_0, nav_bits, gnss_ephemerides_0, nav_bits]
- [gnss_nav_decoding_0_0, '0', gnss_nav_solution_0, '1']
- [gnss_nav_decoding_0_0, nav_bits, gnss_ephemerides_0, nav_bits]
- [gnss_nav_decoding_0_0_0, '0', gnss_nav_solution_0, '2']
- [gnss_nav_decoding_0_0_0, nav_bits, gnss_ephemerides_0, nav_bits]
- [gnss_nav_decoding_0_0_0_0, '0', gnss_nav_solution_0, '3']
- [gnss_nav_decoding_0_0_0_0, nav_bits, gnss_ephemerides_0, nav_bits]
- [gnss_nav_decoding_0_0_0_0_0, '0', gnss_nav_solution_0, '4']
- [gnss_nav_decoding_0_0_0_0_0, nav_bits, gnss_ephemerides_0, nav_bits]
- [gnss_nav_decoding_0_0_0_0_1, '0', gnss_nav_solution_0, '5']
- [gnss_nav_decoding_0_0_0_0_1, nav_bits, gnss_ephemerides_0, nav_bits]
- [gnss_nav_solution_0, '0', qtgui_time_sink_x_0, '0']
- [gnss_tracking_ff_0, '0', gnss_decimator_0, '0']
- [gnss_tracking_ff_0, data_vector, gnss_channel_starter_0_0_0_0, data_vector]
- [gnss_tracking_ff_0_0, '0', gnss_decimator_0_0, '0']
- [gnss_tracking_ff_0_0, data_vector, gnss_channel_starter_0_0_0_0, data_vector]
- [gnss_tracking_ff_0_0_0, '0', gnss_decimator_0_2, '0']
- [gnss_tracking_ff_0_0_0, data_vector, gnss_channel_starter_0_0_0_0_0_0_0, data_vector]
- [gnss_tracking_ff_0_0_0_0, '0', gnss_decimator_0_1, '0']
- [gnss_tracking_ff_0_0_0_0, data_vector, gnss_channel_starter_0_0_0_0_0_0_0, data_vector]
- [gnss_tracking_ff_0_0_0_0_0, '0', gnss_decimator_0_1_0, '0']
- [gnss_tracking_ff_0_0_0_0_0, data_vector, gnss_channel_starter_0_0_0_0_0_0_0_0, data_vector]
- [gnss_tracking_ff_0_0_0_0_0_0, '0', gnss_decimator_0_1_0_0, '0']
- [gnss_tracking_ff_0_0_0_0_0_0, data_vector, gnss_channel_starter_0_0_0_0_0_0_0_0, data_vector]

metadata:
  file_format: 1
